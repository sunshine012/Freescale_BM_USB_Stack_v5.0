# IAR project usbh_bm_twrk70f120m.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: CPU_MK70F12=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pe223,Pe021,Pe375,Pa082
  ICCARM.CCIncludePath2: ../../../../../adapter/sources; ../../../../../adapter/sources/bm; ../../../../../os/bm; ../../../../hal; ../../../sources/classes/audio; ../../../sources/classes/cdc; ../../../sources/classes/hid; ../../../sources/classes/hub; ../../../sources/classes/msd; ../../../sources/classes/phdc; ../../../sources/controller; ../../../sources/controller/ehci; ../../../sources/controller/khci; ../../../include/twrk70f120m; ../../../include; ../../../../include; ../../../../../platform/soc/MK70FN1M012; ../../../../../platform/soc/MK70FN1M012/MK70FN1M012
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  postbuild: ../../../../../usb_core/host/build/bat/usbh_twrk70f120m.bat ../../../../.. ../../../../../output/twrk70f120m.iar/debug/usbh/bm iar bm
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MK70F12=1
  ICCARM.CCOptLevel: 3
  postbuild: ../../../../../usb_core/host/build/bat/usbh_twrk70f120m.bat ../../../../.. ../../../../../output/twrk70f120m.iar/release/usbh/bm iar bm
  ILINK.IlinkOutputFile: libgeneric.out
  group adapter
    ../../../../../adapter/sources/: adapter.h adapter_types.h
    ../../../../../adapter/sources/bm/: adapter_bm.c adapter_bm.h adapter_cfg.h
  group adapter/os
    ../../../../../os/bm/: bmevent.h bmmsgq.h bmsem.h mem_util.h poll.h
  group hal
    ../../../../hal/: fsl_usb_khci_hal.h
  group usb_core/host/sources/class driver/audio
    ../../../sources/classes/audio/: usb_host_audio.c usb_host_audio_intf.c usb_host_audio.h
  group usb_core/host/sources/class driver/cdc
    ../../../sources/classes/cdc/: usb_host_cdc.c usb_host_cdc_intf.c usb_host_cdc.h
  group usb_core/host/sources/class driver/common
    ../../../sources/classes/common/: usb_classes.c
  group usb_core/host/sources/class driver/hid
    ../../../sources/classes/hid/: usb_host_hid.c usb_host_hid.h
  group usb_core/host/sources/class driver/hub
    ../../../sources/classes/hub/: usb_host_hub_prv.h usb_host_hub_sm.c usb_host_hub_sm.h usb_host_hub.c usb_host_hub.h
  group usb_core/host/sources/class driver/msd
    ../../../sources/classes/msd/: usb_host_msd_bo.c usb_host_msd_bo.h usb_host_msd_queue.c usb_host_msd_ufi.c usb_host_msd_ufi.h
  group usb_core/host/sources/class driver/phdc
    ../../../sources/classes/phdc/: usb_host_phdc.c usb_host_phdc.h
  group usb_core/host/sources/controller driver
    ../../../sources/controller/: usb_host_ch9.c usb_host_ch9.h usb_host_common.c usb_host_common.h usb_host_dev_mng.c usb_host_dev_mng.h usb_host.c usb_host.h
  group usb_core/host/sources/controller driver/ehci
    ../../../sources/controller/ehci/: ehci_host.c ehci_prv.h
  group usb_core/host/sources/controller driver/khci
    ../../../sources/controller/khci/: khci.c khci.h khci_prv.h
  group usb_core/host/sources/bsp
    ../../../sources/bsp/twrk70f120m/: usb_host_bsp.c
  group usb_core/host/include
    ../../../include/twrk70f120m/: usb_host_config.h
    ../../../include/: usb_host_stack_interface.h
  group usb_core/include
    ../../../../include/: compiler.h types.h usb_desc.h usb_error.h usb_misc.h usb_opt.h usb_types.h
