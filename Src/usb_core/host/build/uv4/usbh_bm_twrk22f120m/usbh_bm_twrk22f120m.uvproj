# Keil uVision project usbh_bm_twrk22f120m.uvproj, settings and files
target usbh_bm_twrk22f120m Debug (ARM-ADS)
  device: MK22FX512xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) IROM2(0x10000000-0x1001FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: usbh (library)
  AfterMake: ../../../../../usb_core/host/build/bat/usbh_twrk22f120m.bat ../../../../.. ../../../../../output/twrk22f120m.uv4/debug/usbh/bm uv4 bm & ".copy.bat" "Debug/usbh.lib" "../../../../../output/twrk22f120m.uv4/debug/usbh/bm/usbh.lib"
  c flags: Optim=1 OneElfS=1
  c define: SDK_USB_HAL_ENABLE=1, CPU_MK22F51212=1, _DEBUG=1
  c misc: --library_interface=armcc   --library_type=standardlib  --c99  --diag_suppress=223,375
  c include: ../../../../../adapter/sources;../../../../../adapter/sources/bm;../../../../../os/bm;../../../../hal;../../../sources/classes/audio;../../../sources/classes/cdc;../../../sources/classes/hid;../../../sources/classes/hub;../../../sources/classes/msd;../../../sources/classes/phdc;../../../sources/controller;../../../sources/controller/khci;../../../include/twrk22f120m;../../../include;../../../../include;../../../../../platform/soc/MK22F51212;../../../../../platform/soc/MK22F51212/MK22F51212
  asm define: _DEBUG=1
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk22f120m.uv4\mqx\intflash.scf
  group adapter
    ../../../../../adapter/sources/: adapter.h adapter_types.h
    ../../../../../adapter/sources/bm/: adapter_bm.c adapter_bm.h adapter_cfg.h
  group adapter/os
    ../../../../../os/bm/: bmevent.h bmmsgq.h bmsem.h mem_util.h poll.h
  group hal
    ../../../../hal/: fsl_usb_khci_hal.h
  group usb_core/host/sources/class driver/audio
    ../../../sources/classes/audio/: usb_host_audio.c usb_host_audio_intf.c usb_host_audio.h
  group usb_core/host/sources/class driver/cdc
    ../../../sources/classes/cdc/: usb_host_cdc.c usb_host_cdc_intf.c usb_host_cdc.h
  group usb_core/host/sources/class driver/common
    ../../../sources/classes/common/: usb_classes.c
  group usb_core/host/sources/class driver/hid
    ../../../sources/classes/hid/: usb_host_hid.c usb_host_hid.h
  group usb_core/host/sources/class driver/hub
    ../../../sources/classes/hub/: usb_host_hub_prv.h usb_host_hub_sm.c usb_host_hub_sm.h usb_host_hub.c usb_host_hub.h
  group usb_core/host/sources/class driver/msd
    ../../../sources/classes/msd/: usb_host_msd_bo.c usb_host_msd_bo.h usb_host_msd_queue.c usb_host_msd_ufi.c usb_host_msd_ufi.h
  group usb_core/host/sources/class driver/phdc
    ../../../sources/classes/phdc/: usb_host_phdc.c usb_host_phdc.h
  group usb_core/host/sources/controller driver
    ../../../sources/controller/: usb_host_ch9.c usb_host_ch9.h usb_host_common.c usb_host_common.h usb_host_dev_mng.c usb_host_dev_mng.h usb_host.c usb_host.h
  group usb_core/host/sources/controller driver/khci
    ../../../sources/controller/khci/: khci.c khci.h khci_prv.h
  group usb_core/host/include
    ../../../include/twrk22f120m/: usb_host_config.h
    ../../../include/: usb_host_stack_interface.h
  group usb_core/host/sources/bsp
    ../../../sources/bsp/twrk22f120m/: usb_host_bsp.c
  group usb_core/include
    ../../../../include/: compiler.h types.h usb_desc.h usb_error.h usb_misc.h usb_opt.h usb_types.h
target usbh_bm_twrk22f120m Release (ARM-ADS)
  device: MK22FX512xxx12 Freescale Semiconductor
  cpu: as above
  output: usbh (library)
  AfterMake: ../../../../../usb_core/host/build/bat/usbh_twrk22f120m.bat ../../../../.. ../../../../../output/twrk22f120m.uv4/release/usbh/bm uv4 bm & ".copy.bat" "Release/usbh.lib" "../../../../../output/twrk22f120m.uv4/release/usbh/bm/usbh.lib"
  c flags: Optim=4 OneElfS=1
  c define: SDK_USB_HAL_ENABLE=1, CPU_MK22F51212=1
  c misc: as above
  c include: as above
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk22f120m.uv4\mqx\intflash.scf
