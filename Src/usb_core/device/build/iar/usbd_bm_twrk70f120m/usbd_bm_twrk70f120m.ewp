# IAR project usbd_bm_twrk70f120m.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: CPU_MK70F12=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pe223,Pe021,Pe375,Pa082
  ICCARM.CCIncludePath2: ../../../../../adapter/sources; ../../../../../adapter/sources/bm; ../../../../../os/bm; ../../../../hal; ../../../include/twrk70f120m; ../../../include; ../../../sources/classes/audio; ../../../sources/classes/cdc; ../../../sources/classes/common; ../../../sources/classes/composite; ../../../sources/classes/hid; ../../../sources/classes/include; ../../../sources/classes/msd; ../../../sources/classes/phdc; ../../../sources/controller; ../../../sources/controller/ehci; ../../../sources/controller/khci; ../../../../include; ../../../../../platform/soc/MK70FN1M012; ../../../../../platform/soc/MK70FN1M012/MK70FN1M012
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  postbuild: ../../../../../usb_core/device/build/bat/usbd_twrk70f120m.bat ../../../../.. ../../../../../output/twrk70f120m.iar/debug/usbd/bm iar bm
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MK70F12=1
  ICCARM.CCOptLevel: 3
  postbuild: ../../../../../usb_core/device/build/bat/usbd_twrk70f120m.bat ../../../../.. ../../../../../output/twrk70f120m.iar/release/usbd/bm iar bm
  ILINK.IlinkOutputFile: libgeneric.out
  group adapter
    ../../../../../adapter/sources/: adapter.h adapter_types.h
    ../../../../../adapter/sources/bm/: adapter_bm.c adapter_bm.h adapter_cfg.h
  group adapter/os
    ../../../../../os/bm/: bmevent.h bmmsgq.h bmsem.h mem_util.h poll.h
  group hal
    ../../../../hal/: fsl_usb_khci_hal.h
  group usb_core/device/include
    ../../../include/twrk70f120m/: usb_device_config.h
    ../../../include/: usb_device_stack_interface.h
  group usb_core/device/sources/bsp
    ../../../sources/bsp/twrk70f120m/: usb_dev_bsp.c
  group usb_core/device/sources/class driver/audio
    ../../../sources/classes/audio/: usb_audio.c usb_audio.h
  group usb_core/device/sources/class driver/cdc
    ../../../sources/classes/cdc/: usb_cdc_pstn.c usb_cdc_pstn.h usb_cdc.c usb_cdc.h
  group usb_core/device/sources/class driver/common
    ../../../sources/classes/common/: usb_class.c usb_class_internal.h
  group usb_core/device/sources/class driver/composite
    ../../../sources/classes/composite/: usb_composite.c usb_composite.h
  group usb_core/device/sources/class driver/hid
    ../../../sources/classes/hid/: usb_hid.c usb_hid.h
  group usb_core/device/sources/class driver/include
    ../../../sources/classes/include/: usb_class_audio.h usb_class_cdc.h usb_class_composite.h usb_class_hid.h usb_class_msc.h usb_class_phdc.h usb_class.h
  group usb_core/device/sources/class driver/msd
    ../../../sources/classes/msd/: usb_msc_scsi.c usb_msc_scsi.h usb_msc.c usb_msc.h
  group usb_core/device/sources/class driver/phdc
    ../../../sources/classes/phdc/: usb_phdc.c usb_phdc.h
  group usb_core/device/sources/controller driver
    ../../../sources/controller/: ehci_interface.c khci_interface.c usb_dev.c usb_dev.h usb_framework.c usb_framework.h
  group usb_core/device/sources/controller driver/ehci
    ../../../sources/controller/ehci/: ehci_usbprv.h ehci_dev_main.c ehci_dev_main.h
  group usb_core/device/sources/controller driver/khci
    ../../../sources/controller/khci/: khci_dev_misc.h khci_dev.c khci_dev.h
  group usb_core/include
    ../../../../include/: compiler.h types.h usb_desc.h usb_error.h usb_misc.h usb_opt.h usb_types.h
