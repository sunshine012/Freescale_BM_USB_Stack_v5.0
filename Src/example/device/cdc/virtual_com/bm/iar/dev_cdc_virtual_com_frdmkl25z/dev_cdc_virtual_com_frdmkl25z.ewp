# IAR project dev_cdc_virtual_com_frdmkl25z.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CPU_MKL25Z=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pe223,Pe021,Pe375,Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../..; ../../../../../../../platform/arch/cortex_m; ../../../../../../../platform/bsp/common/kinetis; ../../../../../../../platform/bsp/common; ../../../../../../../platform/bsp/peripheral/serial; ../../../../../../../platform/bsp/peripheral/timer; ../../../../../../../platform/bsp/frdmkl25z; ../../../../../../../platform/soc/MKL25Z/MKL25Z4; ../../../../../../../platform/soc/MKL25Z; ../../../../../../../os/bm; ../../../../../../../output/frdmkl25z.iar/debug/usbd/bm
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: frdmkl25z.srec
  ILINK.IlinkOutputFile: dev_cdc_virtual_com.out
  ILINK.IlinkIcfFile: ../../../../../../../platform/bsp/frdmkl25z/iar/MKL25Z128xxx4_DEV_INT_Flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/frdmkl25z.iar/debug/usbd/bm/usbd.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MKL25Z=1
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../..; ../../../../../../../platform/arch/cortex_m; ../../../../../../../platform/bsp/common/kinetis; ../../../../../../../platform/bsp/common; ../../../../../../../platform/bsp/peripheral/serial; ../../../../../../../platform/bsp/peripheral/timer; ../../../../../../../platform/bsp/frdmkl25z; ../../../../../../../platform/soc/MKL25Z/MKL25Z4; ../../../../../../../platform/soc/MKL25Z; ../../../../../../../os/bm; ../../../../../../../output/frdmkl25z.iar/release/usbd/bm
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/frdmkl25z.iar/release/usbd/bm/usbd.a
configuration Int Ram Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../../../../../../../platform/bsp/frdmkl25z/iar/MKL25Z128xxx4_DEV_INT_Ram.icf
configuration Int Ram Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MKL25Z=1
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: as above
  ILINK.IlinkAdditionalLibs: as above
  group Project_Settings/Startup
    ../../../../../../../platform/bsp/frdmkl25z/iar/: cstartup_M.s low_level_init.c
  group Sources/app
    ./: user_config.h
    ../../../: virtual_com.c virtual_com.h usb_descriptor.c usb_descriptor.h
  group Sources/arch
    ../../../../../../../platform/arch/cortex_m/: nvic.c nvic.h
  group Sources/bsp
    ../../../../../../../platform/bsp/common/kinetis/: main_kinetis.c wdt_kinetis.c wdt_kinetis.h
    ../../../../../../../platform/bsp/peripheral/serial/: sci.c sci.h
    ../../../../../../../platform/bsp/common/: hidef.h
    ../../../../../../../platform/bsp/peripheral/timer/: pit_delay.c pit_delay.h rtc_kinetis.c rtc_kinetis.h
  group Sources/bsp/frdmkl25z
    ../../../../../../../platform/bsp/frdmkl25z/: bsp.h derivative.h init_gpio.c
  group Sources/soc
    ../../../../../../../platform/soc/MKL25Z/MKL25Z4/: MKL25Z4.h
    ../../../../../../../platform/soc/MKL25Z/: MKL25Z4_registers.h soc_init.c soc_pit.c soc_isr.c soc_usb.c soc_sci.c soc.h soc_config.h soc_pit.h soc_isr.h soc_sci.h
  group Sources/sys
    ../../../../../../../os/bm/: bmevent.c bmevent.h bmmsgq.c bmmsgq.h bmsem.c bmsem.h bmisr.c mem_util.c mem_util.h poll.c poll.h printf.c
