# Keil uVision project dev_phdc_weighscale_frdmkl25z.uvproj, settings and files
target dev_phdc_weighscale_frdmkl25z Int Flash Debug (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: dev_phdc_weighscale
  c flags: Optim=1 OneElfS=1
  c define: CPU_MKL25Z=1, _DEBUG=1
  c misc: --library_interface=armcc   --library_type=standardlib  --c99  --diag_suppress=223,375
  c include: .;../../..;../../../../../../../platform/arch/cortex_m;../../../../../../../platform/bsp/common/kinetis;../../../../../../../platform/bsp/common;../../../../../../../platform/bsp/peripheral/serial;../../../../../../../platform/bsp/peripheral/timer;../../../../../../../platform/bsp/frdmkl25z;../../../../../../../platform/soc/MKL25Z/MKL25Z4;../../../../../../../platform/soc/MKL25Z;../../../../../../../os/bm;../../../../../../../output/frdmkl25z.uv4/debug/usbd/bm
  asm define: _DEBUG=1
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  link misc: ../../../../../../../output/frdmkl25z.uv4/debug/usbd/bm/usbd.lib

 --diag_suppress=L6314W 

 --remove 

 --autoat
  group Project_Settings/Startup
    ../../../../../../../platform/bsp/frdmkl25z/uv4/: startup.s system.c
  group Sources/app
    ./: user_config.h
    ../../../: phd_com_model.c phd_com_model.h weighscale.c weighscale.h ieee11073_nom_codes.h ieee11073_phd_types.h usb_descriptor.c usb_descriptor.h
  group Sources/arch
    ../../../../../../../platform/arch/cortex_m/: nvic.c nvic.h
  group Sources/bsp
    ../../../../../../../platform/bsp/common/kinetis/: main_kinetis.c wdt_kinetis.c wdt_kinetis.h
    ../../../../../../../platform/bsp/peripheral/serial/: sci.c sci.h
    ../../../../../../../platform/bsp/common/: hidef.h
    ../../../../../../../platform/bsp/peripheral/timer/: pit_delay.c pit_delay.h rtc_kinetis.c rtc_kinetis.h
  group Sources/bsp/frdmkl25z
    ../../../../../../../platform/bsp/frdmkl25z/: bsp.h derivative.h init_gpio.c
  group Sources/soc
    ../../../../../../../platform/soc/MKL25Z/MKL25Z4/: MKL25Z4.h
    ../../../../../../../platform/soc/MKL25Z/: MKL25Z4_registers.h soc_init.c soc_pit.c soc_isr.c soc_usb.c soc_sci.c soc.h soc_config.h soc_pit.h soc_isr.h soc_sci.h
  group Sources/sys
    ../../../../../../../os/bm/: bmevent.c bmevent.h bmmsgq.c bmmsgq.h bmsem.c bmsem.h bmisr.c mem_util.c mem_util.h poll.c poll.h printf.c
target dev_phdc_weighscale_frdmkl25z Int Flash Release (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: as above
  output: dev_phdc_weighscale
  c flags: Optim=4 OneElfS=1
  c define: CPU_MKL25Z=1
  c misc: as above
  c include: .;../../..;../../../../../../../platform/arch/cortex_m;../../../../../../../platform/bsp/common/kinetis;../../../../../../../platform/bsp/common;../../../../../../../platform/bsp/peripheral/serial;../../../../../../../platform/bsp/peripheral/timer;../../../../../../../platform/bsp/frdmkl25z;../../../../../../../platform/soc/MKL25Z/MKL25Z4;../../../../../../../platform/soc/MKL25Z;../../../../../../../os/bm;../../../../../../../output/frdmkl25z.uv4/release/usbd/bm
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  link misc: ../../../../../../../output/frdmkl25z.uv4/release/usbd/bm/usbd.lib

 --diag_suppress=L6314W 

 --remove 

 --autoat
