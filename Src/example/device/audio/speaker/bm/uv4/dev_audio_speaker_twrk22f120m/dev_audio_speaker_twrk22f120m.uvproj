# Keil uVision project dev_audio_speaker_twrk22f120m.uvproj, settings and files
target dev_audio_speaker_twrk22f120m Int Flash Debug (ARM-ADS)
  device: MK22FX512xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) IROM2(0x10000000-0x1001FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: dev_audio_speaker
  c flags: Optim=1 OneElfS=1
  c define: SDK_USB_HAL_ENABLE=1, CPU_MK22F51212=1, _DEBUG=1
  c misc: --library_interface=armcc   --library_type=standardlib  --c99  --diag_suppress=223,375
  c include: .;../../..;../..;../../../../../../../platform/arch/cortex_m;../../../../../../../platform/bsp/common/kinetis;../../../../../../../platform/bsp/common;../../../../../../../platform/bsp/peripheral/serial;../../../../../../../platform/bsp/peripheral/timer;../../../../../../../platform/bsp/twrk22f120m;../../../../../../../platform/soc/MK22F51212/MK22F51212;../../../../../../../platform/soc/MK22F51212;../../../../../../../os/bm;../../../../../../../output/twrk22f120m.uv4/debug/usbd/bm
  asm define: _DEBUG=1
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: ../../../../../../../output/twrk22f120m.uv4/debug/usbd/bm/usbd.lib

 --diag_suppress=L6314W 

 --remove 

 --autoat
  group Project_Settings/Startup
    ../../../../../../../platform/bsp/twrk22f120m/uv4/: startup_MK22F12.s system_MK22F12.c
  group Sources/app
    ./: user_config.h
    ../../../: audio_speaker.c audio_speaker.h usb_request.c usb_request.h usb_descriptor.c usb_descriptor.h
    ../../: sgtl5000.c sgtl5000.h
  group Sources/arch
    ../../../../../../../platform/arch/cortex_m/: nvic.c nvic.h
  group Sources/bsp
    ../../../../../../../platform/bsp/common/kinetis/: main_kinetis.c wdt_kinetis.c wdt_kinetis.h
    ../../../../../../../platform/bsp/twrk22f120m/: init_gpio.c
    ../../../../../../../platform/bsp/peripheral/serial/: sci.c sci.h
    ../../../../../../../platform/bsp/common/: hidef.h
    ../../../../../../../platform/bsp/peripheral/timer/: pit_delay.c pit_delay.h rtc_kinetis.c rtc_kinetis.h
  group Sources/bsp/twrk22f120m
    ../../../../../../../platform/bsp/twrk22f120m/: bsp.h derivative.h
  group Sources/soc
    ../../../../../../../platform/soc/MK22F51212/MK22F51212/: MK22F51212.h
    ../../../../../../../platform/soc/MK22F51212/: MK22F51212_registers.h soc_init.c soc_pit.c soc_i2c.c soc_i2s.c soc_isr.c soc_usb.c soc_sci.c soc.h soc_config.h soc_pit.h soc_isr.h soc_i2c.h soc_i2s.h soc_sci.h
  group Sources/sys
    ../../../../../../../os/bm/: bmevent.c bmevent.h bmmsgq.c bmmsgq.h bmsem.c bmsem.h bmisr.c mem_util.c mem_util.h poll.c poll.h printf.c
target dev_audio_speaker_twrk22f120m Int Flash Release (ARM-ADS)
  device: MK22FX512xxx12 Freescale Semiconductor
  cpu: as above
  output: dev_audio_speaker
  c flags: Optim=4 OneElfS=1
  c define: SDK_USB_HAL_ENABLE=1, CPU_MK22F51212=1
  c misc: as above
  c include: .;../../..;../..;../../../../../../../platform/arch/cortex_m;../../../../../../../platform/bsp/common/kinetis;../../../../../../../platform/bsp/common;../../../../../../../platform/bsp/peripheral/serial;../../../../../../../platform/bsp/peripheral/timer;../../../../../../../platform/bsp/twrk22f120m;../../../../../../../platform/soc/MK22F51212/MK22F51212;../../../../../../../platform/soc/MK22F51212;../../../../../../../os/bm;../../../../../../../output/twrk22f120m.uv4/release/usbd/bm
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: ../../../../../../../output/twrk22f120m.uv4/release/usbd/bm/usbd.lib

 --diag_suppress=L6314W 

 --remove 

 --autoat
