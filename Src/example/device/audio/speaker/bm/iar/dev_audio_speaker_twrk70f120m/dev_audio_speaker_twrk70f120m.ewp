# IAR project dev_audio_speaker_twrk70f120m.ewp, settings and files
configuration Int Ram Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 Freescale MK70FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CPU_MK70F12=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pe223,Pe021,Pe375,Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../..; ../..; ../../../../../../../platform/arch/cortex_m; ../../../../../../../platform/bsp/common/kinetis; ../../../../../../../platform/bsp/common; ../../../../../../../platform/bsp/peripheral/serial; ../../../../../../../platform/bsp/peripheral/timer; ../../../../../../../platform/bsp/twrk70f120m; ../../../../../../../platform/soc/MK70FN1M012/MK70FN1M012; ../../../../../../../platform/soc/MK70FN1M012; ../../../../../../../os/bm; ../../../../../../../output/twrk70f120m.iar/debug/usbd/bm
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: dev_audio_speaker.out
  ILINK.IlinkIcfFile: ../../../../../../../platform/bsp/twrk70f120m/iar/MK70FN1M0_DEV_RAM.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/twrk70f120m.iar/debug/usbd/bm/usbd.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SRAM_DATA_TARGET; CPU_MK70F12=1; _DEBUG=1
  OBJCOPY.OOCOutputFile: twrk70f120m.srec
  ILINK.IlinkIcfFile: ../../../../../../../platform/bsp/twrk70f120m/iar/MK70FN1M0_DEV_Flash.icf
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SRAM_DATA_TARGET; CPU_MK70F12=1
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../..; ../..; ../../../../../../../platform/arch/cortex_m; ../../../../../../../platform/bsp/common/kinetis; ../../../../../../../platform/bsp/common; ../../../../../../../platform/bsp/peripheral/serial; ../../../../../../../platform/bsp/peripheral/timer; ../../../../../../../platform/bsp/twrk70f120m; ../../../../../../../platform/soc/MK70FN1M012/MK70FN1M012; ../../../../../../../platform/soc/MK70FN1M012; ../../../../../../../os/bm; ../../../../../../../output/twrk70f120m.iar/release/usbd/bm
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: as above
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/twrk70f120m.iar/release/usbd/bm/usbd.a
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MK70F12=1
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkAdditionalLibs: as above
  group Project_Settings/Startup
    ../../../../../../../platform/bsp/twrk70f120m/iar/: cstartup_M.s low_level_init.c
  group Sources/app
    ./: user_config.h
    ../../../: audio_speaker.c audio_speaker.h usb_request.c usb_request.h usb_descriptor.c usb_descriptor.h
    ../../: sgtl5000.c sgtl5000.h
  group Sources/arch
    ../../../../../../../platform/arch/cortex_m/: nvic.c nvic.h
  group Sources/bsp
    ../../../../../../../platform/bsp/common/kinetis/: main_kinetis.c wdt_kinetis.c wdt_kinetis.h
    ../../../../../../../platform/bsp/twrk70f120m/: init_gpio.c
    ../../../../../../../platform/bsp/peripheral/serial/: sci.c sci.h
    ../../../../../../../platform/bsp/common/: hidef.h
    ../../../../../../../platform/bsp/peripheral/timer/: pit_delay.c pit_delay.h rtc_kinetis.c rtc_kinetis.h
  group Sources/bsp/twrk70f120m
    ../../../../../../../platform/bsp/twrk70f120m/: bsp.h derivative.h
  group Sources/soc
    ../../../../../../../platform/soc/MK70FN1M012/MK70FN1M012/: MK70F12.h
    ../../../../../../../platform/soc/MK70FN1M012/: MK70FN1M012_registers.h soc_init.c soc_pit.c soc_i2c.c soc_i2s.c soc_isr.c soc_usb.c soc_sci.c soc.h soc_config.h soc_pit.h soc_isr.h soc_i2c.h soc_i2s.h
  group Sources/sys
    ../../../../../../../os/bm/: bmevent.c bmevent.h bmmsgq.c bmmsgq.h bmsem.c bmsem.h bmisr.c mem_util.c mem_util.h poll.c poll.h printf.c
