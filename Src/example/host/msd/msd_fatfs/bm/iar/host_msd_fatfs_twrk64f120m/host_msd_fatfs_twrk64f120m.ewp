# IAR project host_msd_fatfs_twrk64f120m.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK63FN1M0xxx12 Freescale MK63FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1; CPU_MK64F12=1
  ICCARM.CCDiagSuppress: Pe223,Pe021,Pe375,Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../fatfs; ../../../../../../../platform/arch/cortex_m; ../../../../../../../platform/bsp/common/kinetis; ../../../../../../../platform/bsp/common; ../../../../../../../platform/bsp/peripheral/serial; ../../../../../../../platform/bsp/peripheral/timer; ../../../../../../../platform/bsp/twrk64f120m; ../../../../../../../platform/soc/MK64F120M/MK64F12; ../../../../../../../platform/soc/MK64F120M; ../../../../../../../os/bm; ../../../../../../../output/twrk64f120m.iar/debug/usbh/bm
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: twrk64f120m.srec
  ILINK.IlinkOutputFile: host_msd_fatfs.out
  ILINK.IlinkIcfFile: ../../../../../../../platform/bsp/twrk64f120m/iar/MK64FN1M0_HOST_INT_Flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/twrk64f120m.iar/debug/usbh/bm/usbh.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MK64F12=1
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../fatfs; ../../../../../../../platform/arch/cortex_m; ../../../../../../../platform/bsp/common/kinetis; ../../../../../../../platform/bsp/common; ../../../../../../../platform/bsp/peripheral/serial; ../../../../../../../platform/bsp/peripheral/timer; ../../../../../../../platform/bsp/twrk64f120m; ../../../../../../../platform/soc/MK64F120M/MK64F12; ../../../../../../../platform/soc/MK64F120M; ../../../../../../../os/bm; ../../../../../../../output/twrk64f120m.iar/release/usbh/bm
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/twrk64f120m.iar/release/usbh/bm/usbh.a
configuration Int Ram Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../../../../../../../platform/bsp/twrk64f120m/iar/MK64FN1M0_HOST_INT_Ram.icf
configuration Int Ram Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MK64F12=1
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: as above
  ILINK.IlinkAdditionalLibs: as above
  group Project_Settings/Startup
    ../../../../../../../platform/bsp/twrk64f120m/iar/: cstartup_M.s low_level_init.c
  group Sources/app
    ./: user_config.h
    ../../../: main.c
    ../../: msd_fat_demo.c
  group Sources/app/fatfs
    ../../fatfs/: diskio.c diskio.h ff.c ff.h ffconf.h
  group Sources/app/fatfs/option
    ../../fatfs/option/: unicode.c
  group Sources/arch
    ../../../../../../../platform/arch/cortex_m/: nvic.c nvic.h
  group Sources/bsp
    ../../../../../../../platform/bsp/common/kinetis/: main_kinetis.c wdt_kinetis.c wdt_kinetis.h
    ../../../../../../../platform/bsp/peripheral/serial/: sci.c sci.h
    ../../../../../../../platform/bsp/common/: hidef.h
    ../../../../../../../platform/bsp/peripheral/timer/: pit_delay.c pit_delay.h rtc_kinetis.c rtc_kinetis.h
  group Sources/bsp/twrk64f120m
    ../../../../../../../platform/bsp/twrk64f120m/: bsp.h derivative.h init_gpio.c
  group Sources/soc
    ../../../../../../../platform/soc/MK64F120M/MK64F12/: MK64F12.h
    ../../../../../../../platform/soc/MK64F120M/: MK64F120M_registers.h soc_init.c soc_pit.c soc_isr.c soc_usb.c soc_sci.c soc.h soc_config.h soc_pit.h soc_isr.h soc_sci.h
  group Sources/sys
    ../../../../../../../os/bm/: bmevent.c bmevent.h bmmsgq.c bmmsgq.h bmsem.c bmsem.h bmisr.c mem_util.c mem_util.h poll.c poll.h printf.c
