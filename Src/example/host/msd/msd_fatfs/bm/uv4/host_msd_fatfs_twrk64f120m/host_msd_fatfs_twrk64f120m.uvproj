# Keil uVision project host_msd_fatfs_twrk64f120m.uvproj, settings and files
target host_msd_fatfs_twrk64f120m Int Flash Debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2002FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: host_msd_fatfs
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1, CPU_MK64F12=1
  c misc: --library_interface=armcc   --library_type=standardlib  --c99  --diag_suppress=223,375
  c include: .;../../fatfs;../../../../../../../platform/arch/cortex_m;../../../../../../../platform/bsp/common/kinetis;../../../../../../../platform/bsp/common;../../../../../../../platform/bsp/peripheral/serial;../../../../../../../platform/bsp/peripheral/timer;../../../../../../../platform/bsp/twrk64f120m;../../../../../../../platform/soc/MK64F120M/MK64F12;../../../../../../../platform/soc/MK64F120M;../../../../../../../os/bm;../../../../../../../output/twrk64f120m.uv4/debug/usbh/bm
  asm define: _DEBUG=1
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  link misc: ../../../../../../../output/twrk64f120m.uv4/debug/usbh/bm/usbh.lib

 --diag_suppress=L6314W 

 --remove 

 --autoat
  group Project_Settings/Startup
    ../../../../../../../platform/bsp/twrk64f120m/uv4/: startup.s system.c
  group Sources/app
    ./: user_config.h
    ../../../: main.c
    ../../: msd_fat_demo.c
  group Sources/app/fatfs
    ../../fatfs/: diskio.c diskio.h ff.c ff.h ffconf.h
  group Sources/app/fatfs/option
    ../../fatfs/option/: unicode.c
  group Sources/arch
    ../../../../../../../platform/arch/cortex_m/: nvic.c nvic.h
  group Sources/bsp
    ../../../../../../../platform/bsp/common/kinetis/: main_kinetis.c wdt_kinetis.c wdt_kinetis.h
    ../../../../../../../platform/bsp/peripheral/serial/: sci.c sci.h
    ../../../../../../../platform/bsp/common/: hidef.h
    ../../../../../../../platform/bsp/peripheral/timer/: pit_delay.c pit_delay.h rtc_kinetis.c rtc_kinetis.h
  group Sources/bsp/twrk64f120m
    ../../../../../../../platform/bsp/twrk64f120m/: bsp.h derivative.h init_gpio.c
  group Sources/soc
    ../../../../../../../platform/soc/MK64F120M/MK64F12/: MK64F12.h
    ../../../../../../../platform/soc/MK64F120M/: MK64F120M_registers.h soc_init.c soc_pit.c soc_isr.c soc_usb.c soc_sci.c soc.h soc_config.h soc_pit.h soc_isr.h soc_sci.h
  group Sources/sys
    ../../../../../../../os/bm/: bmevent.c bmevent.h bmmsgq.c bmmsgq.h bmsem.c bmsem.h bmisr.c mem_util.c mem_util.h poll.c poll.h printf.c
target host_msd_fatfs_twrk64f120m Int Flash Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale Semiconductor
  cpu: as above
  output: host_msd_fatfs
  c flags: Optim=4 OneElfS=1
  c define: CPU_MK64F12=1
  c misc: as above
  c include: .;../../fatfs;../../../../../../../platform/arch/cortex_m;../../../../../../../platform/bsp/common/kinetis;../../../../../../../platform/bsp/common;../../../../../../../platform/bsp/peripheral/serial;../../../../../../../platform/bsp/peripheral/timer;../../../../../../../platform/bsp/twrk64f120m;../../../../../../../platform/soc/MK64F120M/MK64F12;../../../../../../../platform/soc/MK64F120M;../../../../../../../os/bm;../../../../../../../output/twrk64f120m.uv4/release/usbh/bm
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  link misc: ../../../../../../../output/twrk64f120m.uv4/release/usbh/bm/usbh.lib

 --diag_suppress=L6314W 

 --remove 

 --autoat
