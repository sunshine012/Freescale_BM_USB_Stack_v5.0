# IAR project host_audio_speaker_twrk70f120m.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 Freescale MK70FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SRAM_DATA_TARGET; CPU_MK70F12=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pe223,Pe021,Pe375,Pa082
  ICCARM.CCIncludePath2: ../../..; $PROJ_DIR$; ../../../../../../../platform/arch/cortex_m; ../../../../../../../platform/bsp/common/kinetis; ../../../../../../../platform/bsp/common; ../../../../../../../platform/bsp/peripheral/serial; ../../../../../../../platform/bsp/peripheral/timer; ../../../../../../../platform/bsp/twrk70f120m; ../../../../../../../platform/soc/MK70FN1M012/MK70FN1M012; ../../../../../../../platform/soc/MK70FN1M012; ../../../../../../../os/bm; ../../../../../../../output/twrk70f120m.iar/debug/usbh/bm
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: twrk70f120m.srec
  ILINK.IlinkOutputFile: host_audio_speaker.out
  ILINK.IlinkIcfFile: ../../../../../../../platform/bsp/twrk70f120m/iar/MK70FN1M0_HOST_Flash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/twrk70f120m.iar/debug/usbh/bm/usbh.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SRAM_DATA_TARGET; CPU_MK70F12=1
  ICCARM.CCIncludePath2: ../../..; $PROJ_DIR$; ../../../../../../../platform/arch/cortex_m; ../../../../../../../platform/bsp/common/kinetis; ../../../../../../../platform/bsp/common; ../../../../../../../platform/bsp/peripheral/serial; ../../../../../../../platform/bsp/peripheral/timer; ../../../../../../../platform/bsp/twrk70f120m; ../../../../../../../platform/soc/MK70FN1M012/MK70FN1M012; ../../../../../../../platform/soc/MK70FN1M012; ../../../../../../../os/bm; ../../../../../../../output/twrk70f120m.iar/release/usbh/bm
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/twrk70f120m.iar/release/usbh/bm/usbh.a
  group Project_Settings/Startup
    ../../../../../../../platform/bsp/twrk70f120m/iar/: cstartup_M.s low_level_init.c
  group Sources/app
    ../../../: audio_speaker.c audio_speaker.h hidkeyboard.c hidkeyboard.h audio8k16S.c
    ./: user_config.h
  group Sources/arch
    ../../../../../../../platform/arch/cortex_m/: nvic.c nvic.h
  group Sources/bsp
    ../../../../../../../platform/bsp/common/kinetis/: main_kinetis.c wdt_kinetis.c wdt_kinetis.h
    ../../../../../../../platform/bsp/twrk70f120m/: init_gpio.c
    ../../../../../../../platform/bsp/peripheral/serial/: sci.c sci.h
    ../../../../../../../platform/bsp/common/: hidef.h
    ../../../../../../../platform/bsp/peripheral/timer/: pit_delay.c pit_delay.h rtc_kinetis.c rtc_kinetis.h
  group Sources/bsp/twrk70f120m
    ../../../../../../../platform/bsp/twrk70f120m/: bsp.h derivative.h
  group Sources/soc
    ../../../../../../../platform/soc/MK70FN1M012/MK70FN1M012/: MK70F12.h
    ../../../../../../../platform/soc/MK70FN1M012/: MK70FN1M012_registers.h soc_init.c soc_pit.c soc_isr.c soc_usb.c soc_sci.c soc.h soc_config.h soc_pit.h soc_isr.h soc_sci.h
  group Sources/sys
    ../../../../../../../os/bm/: bmevent.c bmevent.h bmmsgq.c bmmsgq.h bmsem.c bmsem.h bmisr.c mem_util.c mem_util.h poll.c poll.h printf.c
